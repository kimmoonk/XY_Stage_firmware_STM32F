# IAR project Backup (2) of xy.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32F40_41xxx; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\CMSIS\Include; Libraries; Libraries\STM32F4xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: xy.hex
  ILINK.IlinkOutputFile: xy.out
  ILINK.IlinkIcfFile: Libraries\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/: Util.c
  group practice
    ../../마이컴프로그램/test/마이컴1/: EXTINT(Student).c
    ../../마이컴프로그램/test/마이컴2/타이머/: TIM4_PWM_T4CH3(PB8).c
  group xy
    ./: _init.c xy_figure.c xy_main.c
